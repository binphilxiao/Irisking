# Keil uVision project fw.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB 8051 AnchorChips
  cpu: IRAM(0 - 0xFF) CLOCK(25000000) MODDP2
  output: fw +hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Group 1
    ./: FW.C PERIPH.C DSCR.A51
    ../../Lib/LP/: EZUSB.LIB USBJmpTb.OBJ
