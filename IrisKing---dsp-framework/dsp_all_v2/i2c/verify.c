#include "../rsalib/putty.h"
#include "../rsalib/ssh.h"
#include "dbg_printf.h"


static unsigned char public_key[]={
0x00, 0x04, 0x00, 0x00,
0x80, 0x00, 0x00, 0x00,
0xda, 0xef, 0xbc, 0xe2, 0xbf, 0xdd, 0x19, 0xb3,
0x9e, 0xc0, 0xc9, 0xd7, 0x3e, 0xe9, 0xdd, 0x5d,
0xab, 0x62, 0xf5, 0xe0, 0x0f, 0xa2, 0xc5, 0xcf,
0x82, 0x59, 0xac, 0xe0, 0xd5, 0x7b, 0x5f, 0x95,
0x3f, 0x9d, 0xf7, 0xd7, 0x99, 0x59, 0xac, 0xe5,
0xdd, 0xb0, 0x1a, 0x6a, 0x9c, 0x21, 0xac, 0x5a,
0x91, 0xdf, 0xea, 0x3c, 0xb1, 0x80, 0x8a, 0x1c,
0x2b, 0xc8, 0x76, 0xaa, 0xac, 0x68, 0x59, 0x52,
0x54, 0x42, 0x5d, 0xf5, 0xcd, 0xd5, 0x7b, 0xe7,
0x3e, 0xb0, 0xbe, 0x8c, 0x7c, 0x7b, 0x80, 0xc5,
0x2a, 0xa9, 0x8d, 0x3b, 0x82, 0x51, 0x99, 0x74,
0x32, 0x22, 0xb1, 0x4d, 0x2e, 0x75, 0x8a, 0x34,
0xf1, 0x01, 0x1f, 0xe0, 0x12, 0xd4, 0x78, 0x28,
0x89, 0x7e, 0xcc, 0x9e, 0x51, 0x91, 0x08, 0x53,
0xa2, 0x99, 0x07, 0x8b, 0x64, 0x16, 0x11, 0x2c,
0x25, 0x36, 0xb7, 0xeb, 0x16, 0x6b, 0x49, 0xf3,
0x01, 0x00, 0x00, 0x00,
0x8f};


static struct RSAKey key, *p;

int verify_data(unsigned char buf[4 + 8 + 16 + 128])
{
	int len, data_len;
	unsigned char decrypt[256];
	p = &key;

	build_public_key(public_key, p);
	len = buf[4 + 8 + 16 - 1];
	
	if (!(data_len = rsa_decrypt_public(&buf[4 + 8 + 16], len, decrypt, 256, &key)))
	{
		dbg_output("decrypt failed\n");
	}
	if ((data_len != 4 + 8 + 16 - 1) || (memcmp(buf, decrypt, 4 + 8 + 16 - 1) != 0))
	{
		dbg_output("data integrity error\n");
		return 0;
	}
	else
	{
		dbg_output("data integrity ok\n");
		return 1;
	}
	freersakey(p);

	return 1;
}

int generate_key(unsigned char key[8], unsigned char* buf)
{
	unsigned char init[] = "Beijing Irisking Tech. Ltd.";
	unsigned char dig[20];
	int i;

	SHA_State s;

	SHA_Init(&s);
	SHA_Bytes(&s, init, strlen(init));
	SHA_Bytes(&s, buf, 4 + 8 + 16); 
	SHA_Final(&s, dig);

	memcpy(key, dig, 8);
	for (i = 8; i < 20 - 8; i++)
	{
		key[i % 8] ^= dig[i];
	}

}
