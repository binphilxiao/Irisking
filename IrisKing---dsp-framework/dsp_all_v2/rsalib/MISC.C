/*
 * Platform-independent routines shared between all PuTTY programs.
 */

#include <stdio.h>
#include <stdlib.h>
#include <limits.h>
#include <ctype.h>
#include "ssh.h"
#include "putty.h"
#include "dbg_printf.h"

unsigned char public_key[]={
0x00, 0x04, 0x00, 0x00,
0x80, 0x00, 0x00, 0x00,
0xdc, 0x4c, 0x1a, 0xfd, 0x00, 0x78, 0x86, 0x94,
0x19, 0x08, 0x28, 0xbf, 0x51, 0xed, 0x38, 0x7a,
0xf9, 0x4e, 0x2b, 0xd2, 0xe9, 0x9f, 0xbd, 0xf7,
0xda, 0x89, 0xac, 0xde, 0x4a, 0x35, 0xb3, 0x14,
0x73, 0x8a, 0xe1, 0xc3, 0x46, 0x79, 0xe5, 0xfc,
0x0a, 0xbe, 0xd6, 0x42, 0xe7, 0x63, 0x35, 0xbc,
0x64, 0x16, 0x76, 0x5c, 0x7e, 0xaf, 0x62, 0x15,
0x31, 0x29, 0x4a, 0x00, 0x1b, 0x1c, 0xe0, 0x53,
0xf3, 0x96, 0xc3, 0xfa, 0xeb, 0xd2, 0x64, 0x62,
0xd9, 0x6f, 0xfc, 0x39, 0x4e, 0x89, 0x36, 0xa7,
0xfc, 0x5a, 0xf8, 0x4e, 0x5e, 0xda, 0x12, 0x4a,
0x52, 0xd5, 0x24, 0x85, 0x12, 0x04, 0x7c, 0xaf,
0x25, 0x26, 0x6a, 0x9d, 0x26, 0x6e, 0x04, 0xee,
0x85, 0xaf, 0xa7, 0x40, 0x3c, 0xb2, 0xae, 0x9a,
0x25, 0xe8, 0x86, 0x8f, 0x6a, 0x8e, 0x50, 0x75,
0x6e, 0x91, 0x6d, 0x06, 0x08, 0x83, 0x2f, 0xfb,
0x01, 0x00, 0x00, 0x00,
0x8f};


unsigned char private_key[]={
0x00, 0x04, 0x00, 0x00,
0x80, 0x00, 0x00, 0x00,
0xdc, 0x4c, 0x1a, 0xfd, 0x00, 0x78, 0x86, 0x94,
0x19, 0x08, 0x28, 0xbf, 0x51, 0xed, 0x38, 0x7a,
0xf9, 0x4e, 0x2b, 0xd2, 0xe9, 0x9f, 0xbd, 0xf7,
0xda, 0x89, 0xac, 0xde, 0x4a, 0x35, 0xb3, 0x14,
0x73, 0x8a, 0xe1, 0xc3, 0x46, 0x79, 0xe5, 0xfc,
0x0a, 0xbe, 0xd6, 0x42, 0xe7, 0x63, 0x35, 0xbc,
0x64, 0x16, 0x76, 0x5c, 0x7e, 0xaf, 0x62, 0x15,
0x31, 0x29, 0x4a, 0x00, 0x1b, 0x1c, 0xe0, 0x53,
0xf3, 0x96, 0xc3, 0xfa, 0xeb, 0xd2, 0x64, 0x62,
0xd9, 0x6f, 0xfc, 0x39, 0x4e, 0x89, 0x36, 0xa7,
0xfc, 0x5a, 0xf8, 0x4e, 0x5e, 0xda, 0x12, 0x4a,
0x52, 0xd5, 0x24, 0x85, 0x12, 0x04, 0x7c, 0xaf,
0x25, 0x26, 0x6a, 0x9d, 0x26, 0x6e, 0x04, 0xee,
0x85, 0xaf, 0xa7, 0x40, 0x3c, 0xb2, 0xae, 0x9a,
0x25, 0xe8, 0x86, 0x8f, 0x6a, 0x8e, 0x50, 0x75,
0x6e, 0x91, 0x6d, 0x06, 0x08, 0x83, 0x2f, 0xfb,
0x80, 0x00, 0x00, 0x00,
0x89, 0xf3, 0xfd, 0xaf, 0xe4, 0xdf, 0x7f, 0x67,
0xd9, 0x06, 0x70, 0x3a, 0x43, 0x7d, 0xa8, 0x88,
0xe8, 0xde, 0xf7, 0x7d, 0x0f, 0xed, 0x88, 0x35,
0x97, 0xa9, 0xd4, 0xdf, 0x6c, 0x97, 0x89, 0xfe,
0xc0, 0xba, 0x2f, 0xb5, 0xd7, 0x68, 0xe2, 0xae,
0x55, 0x82, 0x05, 0x29, 0xff, 0xcf, 0xde, 0xd6,
0xcc, 0x53, 0x4a, 0x79, 0x68, 0xd4, 0xe8, 0x33,
0x7e, 0xe3, 0x67, 0x81, 0x79, 0x5d, 0x46, 0x6c,
0x95, 0xdd, 0x2a, 0x37, 0x74, 0xbe, 0x55, 0xe8,
0x1d, 0xa7, 0x38, 0x33, 0x9d, 0x45, 0x6f, 0x9d,
0x0f, 0xdb, 0xb5, 0x5a, 0xe2, 0xf4, 0x2b, 0x02,
0x73, 0xc2, 0xb6, 0x18, 0x96, 0xe2, 0x0c, 0x96,
0x81, 0x84, 0xb6, 0x63, 0xdc, 0x75, 0x0e, 0x8f,
0xad, 0x6f, 0x7c, 0x9a, 0x84, 0x93, 0x83, 0xf0,
0x8b, 0xd1, 0xc0, 0xbf, 0xc4, 0xbc, 0x7c, 0x92,
0x97, 0x15, 0x30, 0x8c, 0x75, 0x8d, 0xa2, 0x13};


void *safemalloc(size_t n, size_t size)
{
    void *p;

    if (n > INT_MAX / size) {
		p = NULL;
    } else {
		size *= n;
		if (size == 0) size = 1;
		p = malloc(size);
    }

    if (!p) {
		while(1);
    }
    return p;
}

void *saferealloc(void *ptr, size_t n, size_t size)
{
    void *p;

    if (n > INT_MAX / size) {
	p = NULL;
    } else {
		size *= n;
		if (!ptr) {
			p = malloc(size);
		} else {
			p = realloc(ptr, size);
		}
    }

    if (!p) {
		while(1);
    }
    return p;
}

void safefree(void *ptr)
{
    if (ptr) {
		free(ptr);
    }
}

/* ----------------------------------------------------------------------
 * Debugging routines.
 */


int random_byte(void)
{
	return rand();
}

void dump_char(unsigned char c)
{
	dbg_output( "0x%02x", c);
}

int dump_int(unsigned int n)
{
	int i;
	unsigned char* p = (unsigned char *)&n;
	for (i = 0; i < 4; i++)
	{
		dump_char(p[i]);
		dbg_output( ", ");
	}
	return 0;
}

int dump_bignum(Bignum bn)
{
	int len, i, j;
	char *p;
	len = ((bignum_bitcount(bn) + 7) >> 3);
	p = malloc(len);
	dump_int(len);
	dbg_output( "\n");

	j = 1;
	for (i = len - 1; i >= 0; i--, j++)
	{
		dump_char(bignum_byte(bn, i) ^ 0xaa);
		if (i)
			dbg_output( ", ");
		if ((j % 8 == 0) && i)
			dbg_output( "\n");
	}
	return 0;
}

int dump_key(struct RSAKey *key)
{
	dbg_output( "unsigned char public_key[]={\n");

	dump_int(key->bits);	
	dbg_output( "\n");

	dump_bignum(key->modulus);
	dbg_output( ",\n");

	dump_bignum(key->exponent);
	dbg_output( "};\n");
	dbg_output( "\n");
	dbg_output( "\n");

	dbg_output( "unsigned char private_key[]={\n");
	dump_int(key->bits);	
	dbg_output( "\n");
	dump_bignum(key->modulus);
	dbg_output( ",\n");
	dump_bignum(key->private_exponent);
	dbg_output( "};\n");
	dbg_output( "\n");
	return 0;
}

static int buf_get_int(unsigned char **buf)
{
	int i;
	memcpy(&i, *buf, 4);
	*buf += 4;
	return i;
}


int build_public_key(unsigned char* buf, struct RSAKey *key)
{
	int len, i;
	key->bits = buf_get_int(&buf);
	key->bytes = ((key->bits + 7) >> 3);
	
	len = buf_get_int(&buf);

	for (i = 0; i < len; i++)
		buf[i] ^= 0xaa;
	key->modulus = bignum_from_bytes(buf, len);
	buf += len;
	len = buf_get_int(&buf);
	for (i = 0; i < len; i++)
		buf[i] ^= 0xaa;
	key->exponent = bignum_from_bytes(buf, len);
	return 0;
}

int build_private_key(unsigned char* buf, struct RSAKey *key)
{
	int len, i;
	key->bits = buf_get_int(&buf);
	key->bytes = ((key->bits + 7) >> 3);
	
	len = buf_get_int(&buf);
	for (i = 0; i < len; i++)
		buf[i] ^= 0xaa;
	key->modulus = bignum_from_bytes(buf, len);
	buf += len;
	len = buf_get_int(&buf);
	for (i = 0; i < len; i++)
		buf[i] ^= 0xaa;
	key->private_exponent = bignum_from_bytes(buf, len);
	return 0;
}

void test_rsa()
{
	int i, j, len;
	char buf[256];
	char encrypt[256];
	char decrypt[256];
	int len1 = 48;
	struct RSAKey *key;
	key = safemalloc(1, sizeof(struct RSAKey));
	
	dbg_output("start\n");

	build_public_key(public_key, key);
	build_private_key(private_key, key);

	for (len1 = 110; len1 < 128; len1 ++)
	{
		for (j = 0; j < 10; j++)
		{
			for (i = 0; i< 256; i++)
			{
				buf[i] = random_byte();
			}

			dbg_output("len %d ", len1);

			if (!(len = rsa_encrypt_public(buf, len1, encrypt, 256, key)))
			{
				dbg_output("encrypt failed\n");
				continue;
			}

			if (!(len = rsa_decrypt_private(encrypt, len, decrypt, 256, key)))
			{
				dbg_output("decrypt failed\n");
				continue;
			}
			
			if (memcmp(decrypt, buf, len1) == 0)
				dbg_output("equal\n");
			else
				dbg_output("not equal\n");
		}
	}
	freersakey(key);
	safefree(key);
}
